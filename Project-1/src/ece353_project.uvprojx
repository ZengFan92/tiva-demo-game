# Keil uVision project ece353_project.uvprojx, settings and files
target ECE353-Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c interrupts.c boardUtil.c boardUtil.h game.c
  group driver
    ../drivers/: adc.c eeprom.c gpioPort.c i2c.c io_expander.c ledMatrixChars.c pc_buffer.c spi.c timer0.c uart.c wireless.c fonts.c lcd.c watchdog0.c
  group include
    ../include/: adc.h circular_buffer.h eeprom.h gpio.h gpioPort.h i2c.h io_expander.h lcd.h ledMatrixChars.h mcp23017.h pc_buffer.h spi.h sysctrl.h systick.h timer0.h uart.h wireless.h marios.h game.h
    ./: main.h
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
